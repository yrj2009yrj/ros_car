# Keil uVision project ros_car.uvprojx, settings and files
target ros_base (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ros_car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\User\usart;.\User\SysTick;.\User\PID;.\User\contact;.\User\UltrasonicWave;.\User\spin;.\User\encoder;.\User\GPIO_conf;.\User\NVIC_conf;.\User\RCC_Conf;.\User\TIM2_5_6;.\User\usart;.\User\encoder;.\User\Delay;.\User\Odometry;.\User\IWDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./User/: main.c stm32f10x_it.c
  group System
    ./User/Delay/: delay.c
    ./User/NVIC_conf/: nvic_conf.c
    ./User/RCC_Conf/: rcc_conf.c
    ./User/GPIO_conf/: gpio_conf.c
    ./User/usart/: usart.c
  group Hardware
    ./User/Odometry/: odometry.c
    ./User/TIM2_5_6/: tim2_5_6.c
    ./User/contact/: contact.c
    ./User/encoder/: encoder.c
    ./User/PID/: PID.C
  group DOC
    ./User/Doc/: readme.txt
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
